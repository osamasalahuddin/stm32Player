# Keil uVision project Project.uvprojx, settings and files
target STM32F103RB_Nucleo (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.0.0
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: STM32F103RB_Nucleo
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xB,USE_STM32F1xx_NUCLEO,SD_GET_STATUS_WORKAROUND, TRACE_ENABLE, ERROR_ENABLE, WARNING_ENABLE
  c misc: --C99 -Ono_fp_formats
  c include: ../Inc;../../../../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../../../../Drivers/STM32F1xx_HAL_Driver/Inc;../../../../Drivers/BSP/STM32F1xx_Nucleo;../../../../Drivers/BSP/Components;../../../../Drivers/BSP/Components/Common;..\Debug;..\..\..\..\Drivers\CMSIS\Include;..\..\..\..\Drivers\BSP\VS1053\Inc;../../../../Middlewares/Third_Party/FatFs/src;../../../../Middlewares/Third_Party/FatFs/src/drivers;../../../../Drivers/BSP/Adafruit_Shield
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  link misc: --diag_suppress=L6329
  group Drivers/BSP/STM32F1xx_Nucleo
    ../../../../Drivers/BSP/STM32F1xx_Nucleo/: stm32f1xx_nucleo.c
  group Drivers/STM32F1xx_HAL_Driver
    ../../../../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_cortex.c stm32f1xx_hal_adc.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_spi.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal_uart.c
  group Demo/MDK-ARM
    ./: startup_stm32f103xb.s
  group Demo/User
    ../Src/: stm32f1xx_it.c main.c stm32f1xx_hal_msp.c
  group Drivers/CMSIS
    ../Src/: system_stm32f1xx.c
  group Debug
    ../Debug/: Debug.c printf.c time.c
  group Drivers/BSP/VS1053
    ../../../../Drivers/BSP/VS1053/Src/: VS1053.c
  group Middlewares/FatFs/Core
    ../../../../Middlewares/Third_Party/FatFs/src/: diskio.c ff.c ff_gen_drv.c
  group Drivers/BSP/Adafruit_Shield
    ../../../../Drivers/BSP/Adafruit_Shield/: stm32_adafruit_sd.c
  group Middlewares/FatFs/Drivers
    ../../../../Middlewares/Third_Party/FatFs/src/drivers/: sd_diskio.c
software components: CMSIS:CORE 4.1.0
