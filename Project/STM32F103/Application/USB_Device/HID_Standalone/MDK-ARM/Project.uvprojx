# Keil uVision project Project.uvprojx, settings and files
target STM32F103RB_Nucleo (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.0.0
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: STM32F103RB_Nucleo
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xB,USE_STM32F1xx_NUCLEO
  c misc: --C99
  c include: ../Inc;../../../../../../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../../../../../../Drivers/STM32F1xx_HAL_Driver/Inc;../../../../../../Drivers/BSP/STM32F1xx_Nucleo;../../../../../../Middlewares/ST/STM32_USB_Device_Library/Core/Inc;../../../../../../Middlewares/ST/STM32_USB_Device_Library/Class/HID/Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  link misc: --diag_suppress=L6329
  group Drivers/BSP/STM32F1xx_Nucleo
    ../../../../../../Drivers/BSP/STM32F1xx_Nucleo/: stm32f1xx_nucleo.c
  group Drivers/STM32F1xx_HAL_Driver
    ../../../../../../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_pcd_ex.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pcd.c stm32f1xx_hal_uart.c stm32f1xx_hal_dma.c stm32f1xx_hal_rtc_ex.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_rtc.c stm32f1xx_ll_usb.c
  group Middlewares/STM32_USBD_Library/Class/HID
    ../../../../../../Middlewares/ST/STM32_USB_Device_Library/Class/HID/Src/: usbd_hid.c
  group Doc
    ../: readme.txt
  group Middlewares/STM32_USBD_Library/Core
    ../../../../../../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_ioreq.c usbd_ctlreq.c usbd_core.c
  group Application/MDK-ARM
    ./: startup_stm32f103xb.s
  group Application/User
    ../Src/: main.c usbd_conf.c stm32f1xx_it.c usbd_desc.c
  group Drivers/CMSIS
    ../Src/: system_stm32f1xx.c
software components: CMSIS:CORE 4.1.0
